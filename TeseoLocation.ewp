# IAR project TeseoLocation.ewp, settings and files
configuration TeseoLocation (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050,Pa084,Pa093,Pa082
  ICCARM.IExtraOptions: -DDEVICE_RTC=1; -DTARGET_NUCLEO_F401RE; -DDEVICE_SLEEP=1; -DTOOLCHAIN_object; -DARM_MATH_CM4; --guard_calls; --preinclude=mbed_config.h; -DTARGET_STM32F401RE; -DTARGET_STM32F4; --diag_suppress=Pa050,Pa084,Pa093,Pa082; -DDEVICE_PORTINOUT=1; -e; -DTARGET_FF_MORPHO; -DDEVICE_I2C_ASYNCH=1; -DTARGET_FF_ARDUINO; -DTARGET_RTOS_M4_M7; -DDEVICE_SPISLAVE=1; -DDEVICE_PORTOUT=1; -DDEVICE_STDIO_MESSAGES=1; -DTARGET_RELEASE; -DTARGET_LIKE_MBED; -DDEVICE_SERIAL_FC=1; -DDEVICE_INTERRUPTIN=1; -DDEVICE_ANALOGIN=1; -DTARGET_LIKE_CORTEX_M4; -D__CORTEX_M4; -DDEVICE_ERROR_RED=1; -DTARGET_CORTEX_M; -DDEVICE_SERIAL=1; -DUSB_STM_HAL; -DDEVICE_I2C=1; -DDEVICE_PORTIN=1; -DTARGET_STM; -DTARGET_UVISOR_UNSUPPORTED; -DUSBHOST_OTHER; --no_wrap_diagnostics; -DDEVICE_PWMOUT=1; -DDEVICE_SERIAL_ASYNCH=1; -DDEVICE_SPI=1; -D__MBED__=1; -DTOOLCHAIN_IAR; -DMBED_BUILD_TIMESTAMP=1497949043.18; -DTARGET_STM32F401xE; -DTARGET_M4; -D__FPU_PRESENT=1; -DDEVICE_I2CSLAVE=1; -D__CMSIS_RTOS; -DDEVICE_SPI_ASYNCH=1; -DTRANSACTION_QUEUE_SIZE_SPI=2; -D__MBED_CMSIS_RTOS_CM
  ICCARM.CCIncludePath2: .; X_NUCLEO_GNSS1A1; X_NUCLEO_GNSS1A1/Components; X_NUCLEO_GNSS1A1/Components/Teseo; X_NUCLEO_GNSS1A1/Middlewares; GPSProvider; mbed/.; mbed/TARGET_NUCLEO_F401RE; mbed/TARGET_NUCLEO_F401RE/TARGET_STM; mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4; mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_STM32F401xE; mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_STM32F401xE/TARGET_NUCLEO_F401RE; mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_STM32F401xE/device; mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/device; mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR; mbed/drivers; mbed/hal; mbed/platform; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -DTRANSACTION_QUEUE_SIZE_SPI=2; -D__CORTEX_M4; -DUSB_STM_HAL; -DARM_MATH_CM4; -D__FPU_PRESENT=1; -DUSBHOST_OTHER; -D__MBED_CMSIS_RTOS_CM; -D__CMSIS_RTOS
  OBJCOPY.OOCOutputFile: TeseoLocation.srec
  ILINK.IlinkOutputFile: name.out
  ILINK.IlinkIcfFile: mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f401xe.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --threaded_lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group GPSProvider
    GPSProvider/: GPSGeofence.h GPSProvider.cpp GPSProvider.h GPSProviderImplBase.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/: analogin_api.o analogout_api.o can_api.o cmain.o cmsis_nvic.o gpio_api.o gpio_irq_api.o gpio_irq_device.o hal_init_pre.o hal_tick_16b.o hal_tick_32b.o i2c_api.o lp_ticker.o mbed.a mbed_board.o mbed_overrides.o mbed_retarget.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o pwmout_device.o rtc_api.o serial_api.o sleep.o spi_api.o startup_stm32f401xe.o stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal_can.o stm32f4xx_hal_cec.o stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.o stm32f4xx_hal_cryp.o stm32f4xx_hal_cryp_ex.o stm32f4xx_hal_dac.o stm32f4xx_hal_dac_ex.o stm32f4xx_hal_dcmi.o stm32f4xx_hal_dcmi_ex.o stm32f4xx_hal_dfsdm.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma2d.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_dsi.o stm32f4xx_hal_eth.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_flash_ramfunc.o stm32f4xx_hal_fmpi2c.o stm32f4xx_hal_fmpi2c_ex.o stm32f4xx_hal_gpio.o stm32f4xx_hal_hash.o stm32f4xx_hal_hash_ex.o stm32f4xx_hal_hcd.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_i2s.o stm32f4xx_hal_i2s_ex.o stm32f4xx_hal_irda.o stm32f4xx_hal_iwdg.o stm32f4xx_hal_lptim.o stm32f4xx_hal_ltdc.o stm32f4xx_hal_ltdc_ex.o stm32f4xx_hal_msp_template.o stm32f4xx_hal_nand.o stm32f4xx_hal_nor.o stm32f4xx_hal_pccard.o stm32f4xx_hal_pcd.o stm32f4xx_hal_pcd_ex.o stm32f4xx_hal_pwr.o stm32f4xx_hal_pwr_ex.o stm32f4xx_hal_qspi.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rng.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_sai.o stm32f4xx_hal_sai_ex.o stm32f4xx_hal_sd.o stm32f4xx_hal_sdram.o stm32f4xx_hal_smartcard.o stm32f4xx_hal_spdifrx.o stm32f4xx_hal_spi.o stm32f4xx_hal_sram.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o stm32f4xx_hal_usart.o stm32f4xx_hal_wwdg.o stm32f4xx_ll_fmc.o stm32f4xx_ll_fsmc.o stm32f4xx_ll_sdmmc.o stm32f4xx_ll_usb.o stm_spi_api.o system_stm32f4xx.o trng_api.o us_ticker_16b.o us_ticker_32b.o
    mbed/TARGET_NUCLEO_F401RE/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/: can_device.h common_objects.h device.h gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.h
    mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_STM32F401xE/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32f401xe.h stm32f4xx.h system_stm32f4xx.h
    mbed/TARGET_NUCLEO_F401RE/TARGET_STM/: gpio_object.h mbed_rtx.h PeripheralPins.h PinNamesTypes.h PortNames.h rtc_api_hal.h
    mbed/: mbed.h
    mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_STM32F401xE/: objects.h
    mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_STM32F401xE/TARGET_NUCLEO_F401RE/: PeripheralNames.h PinNames.h
    mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/device/: stm32_hal_legacy.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h
  group TeseoLocation
    ./: main.cpp mbed_config.h
  group X_NUCLEO_GNSS1A1
    X_NUCLEO_GNSS1A1/: createTeseoGNSS.cpp TeseoConfig.h
    X_NUCLEO_GNSS1A1/Middlewares/: NMEAParser.c NMEAParser.h NMEAUtils.c NMEAUtils.h
    X_NUCLEO_GNSS1A1/Components/Teseo/: Teseo.cpp Teseo.h
